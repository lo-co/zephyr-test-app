## tests/test_tests/testcase.yaml
```yaml
tests:
  test.testing.framework:
    platform_allow: native_sim
    harness: ztest
    tags: mytag
```
